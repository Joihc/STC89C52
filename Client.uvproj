# Keil uVision project Client.uvproj, settings and files
target project (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Client +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\include
  group start
    ./: STARTUP.A51
  group include
    ./include/: config.h lcd12864.h led.h main.h time.h time0.h time1.h usart.h button.h menu1.h menu2.h menu3.h
  group source
    ./source/: lcd12864.c led.c main.c time.c time0.c time1.c usart.c button.c menu1.c menu2.c menu3.c
